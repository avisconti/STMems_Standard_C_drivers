# IAR project _prj_NucleoF401.ewp, settings and files
configuration _prj_NucleoF401 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; NUCLEO_F401RE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; C:\Users\visconta\Projects\STdC\lsm6dsv16x_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\FIFO_Utility_Tool; C:\Users\visconta\Projects\STdC\lsm6dsv16bx_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dsv32x_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv16x\Glance detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv16x\FourD position recognition; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lsm6dsv16x\gym_activity_recognition; C:\Users\visconta\Projects\STdC\lsm6dsv16b_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lsm6dsv16bx\activity_recognition_for_wrist; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv16bx\Glance detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv16bx\FourD position recognition; C:\Users\visconta\Projects\STdC\lsm6dsv_STdC\driver; C:\Users\visconta\Projects\STdC\lis2mdl_STdC\driver; C:\Users\visconta\Projects\STdC\lps22df_STdC\driver; C:\Users\visconta\Projects\STdC\lis2dw12_STdC\driver; C:\Users\visconta\Projects\STdC\lis2doc_STdC\driver; C:\Users\visconta\Projects\STdC\lis2du12_STdC\driver; C:\Users\visconta\Projects\STdC\lis2dux12_STdC\driver; C:\Users\visconta\Projects\STdC\lis2duxs12_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dso16is_STdC\driver; C:\Users\visconta\Projects\STdC\ism330is_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\ispu-examples\ism330is_lsm6dso16is\norm\output; C:\Users\visconta\Projects\STdC\sths34pf80_STdC\driver; C:\Users\visconta\Projects\STdC\asm330lhh_STdC\driver; C:\Users\visconta\Projects\STdC\asm330lhm_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6ds3_STdC\driver; C:\Users\visconta\Projects\STdC\lps22hb_STdC\driver; C:\Users\visconta\Projects\STdC\iis3dwb_STdC\driver; C:\Users\visconta\Projects\STdC\ilps22qs_STdC\driver; C:\Users\visconta\Projects\STdC\ilps28qsw_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dso_STdC\driver; C:\Users\visconta\Projects\STdC\lps22hh_STdC\driver; C:\Users\visconta\Projects\STdC\lps28dfw_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dsox_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\configuration_examples\example_5_profi_unico\4_ucf; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lsm6dsox\Yoga pose recognition; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsox\Glance detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lsm6dsox\Vibration monitoring; C:\Users\visconta\Projects\STdC\lsm6dso32x_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lsm6dso32x\Vibration monitoring; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lis2duxs12\Glance detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lis2dux12\Glance detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lis2duxs12\activity_recognition_for_mobile; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lis2dux12\activity_recognition_for_mobile; C:\Users\visconta\Projects\STdC\lis2dtw12_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dsvd_STdC\driver; C:\Users\visconta\Projects\STdC\steng1ax_STdC\driver; C:\Users\visconta\Projects\STdC\asm330lhhxg1_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\asm330lhhx\Shake detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\asm330lhhx\Motion-Stationary detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\asm330lhhx\Vehicle stationary detection; C:\Users\visconta\Projects\STdC\lsm6dsv256x_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dsv320x_STdC\driver; C:\Users\visconta\Projects\STdC\lis3dh_STdC\driver; C:\Users\visconta\Projects\STdC\lis2hh12_STdC\driver; C:\Users\visconta\Projects\STdC\a3g4250d_STdC\driver; C:\Users\visconta\Projects\STdC\ais2dw12_STdC\driver; C:\Users\visconta\Projects\STdC\ais2ih_STdC\driver; C:\Users\visconta\Projects\STdC\ais328dq_STdC\driver; C:\Users\visconta\Projects\STdC\ais3624dq_STdC\driver; C:\Users\visconta\Projects\STdC\asm330lhb_STdC\driver; C:\Users\visconta\Projects\STdC\asm330lhhx_STdC\driver; C:\Users\visconta\Projects\STdC\h3lis100dl_STdC\driver; C:\Users\visconta\Projects\STdC\h3lis331dl_STdC\driver; C:\Users\visconta\Projects\STdC\hts221_STdC\driver; C:\Users\visconta\Projects\STdC\i3g4250d_STdC\driver; C:\Users\visconta\Projects\STdC\iis2dh_STdC\driver; C:\Users\visconta\Projects\STdC\iis2dlpc_STdC\driver; C:\Users\visconta\Projects\STdC\iis2iclx_STdC\driver; C:\Users\visconta\Projects\STdC\iis2mdc_STdC\driver; C:\Users\visconta\Projects\STdC\iis328dq_STdC\driver; C:\Users\visconta\Projects\STdC\iis3dhhc_STdC\driver; C:\Users\visconta\Projects\STdC\ism303dac_STdC\driver; C:\Users\visconta\Projects\STdC\ism330dhcx_STdC\driver; C:\Users\visconta\Projects\STdC\ism330dlc_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\ism330dhcx\Freefall detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\iis2iclx\Tilt detection; C:\Users\visconta\Projects\STdC\l3gd20h_STdC\driver; C:\Users\visconta\Projects\STdC\lis2de12_STdC\driver; C:\Users\visconta\Projects\STdC\lis2dh12_STdC\driver; C:\Users\visconta\Projects\STdC\lis2dh_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dsv32x_STdC\driver; C:\Users\visconta\Projects\STdC\ism330bx_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv32x\Glance detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv32x\FourD position recognition; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lsm6dsv32x\gym_activity_recognition; C:\Users\visconta\Projects\STdC\asm330lhbg1_STdC\driver; C:\Users\visconta\Projects\STdC\st1vafe6ax_STdC\driver; C:\Users\visconta\Projects\STdC\stts22h_STdC\driver; C:\Users\visconta\Projects\STdC\lps25hb_STdC\driver; C:\Users\visconta\Projects\STdC\lps33k_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\ism330bx\tilt_angle_mode0; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\ism330bx\Vibration monitoring; C:\Users\visconta\Projects\STdC\lps28dfw5_STdC\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: _prj_NucleoF401.hex
  ILINK.IlinkOutputFile: _prj_NucleoF401.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: gpio.c i2c.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group MEMS/a3g4250d
    ../../a3g4250d_STdC/examples/: a3g4250d_fifo_read.c a3g4250d_read_data_polling.c a3g4250d_wake_up.c
    ../../a3g4250d_STdC/driver/: a3g4250d_reg.c
  group MEMS/ais25ba
    ../../ais25ba_STdC/driver/: ais25ba_reg.c
  group MEMS/ais2dw12
    ../../ais2dw12_STdC/examples/: ais2dw12_activity.c ais2dw12_free_fall.c ais2dw12_orientation.c ais2dw12_read_data_polling.c ais2dw12_read_fifo.c ais2dw12_self_test.c ais2dw12_wake_up.c
    ../../ais2dw12_STdC/driver/: ais2dw12_reg.c
  group MEMS/ais2ih
    ../../ais2ih_STdC/examples/: ais2ih_activity.c ais2ih_free_fall.c ais2ih_orientation.c ais2ih_read_data_polling.c ais2ih_read_data_single.c ais2ih_read_fifo.c ais2ih_self_test.c ais2ih_tap_double.c ais2ih_tap_single.c ais2ih_wake_up.c
    ../../ais2ih_STdC/driver/: ais2ih_reg.c
  group MEMS/ais328dq
    ../../ais328dq_STdC/examples/: ais328dq_read_data_polling.c ais328dq_self_test.c ais328dq_wake_up.c
    ../../ais328dq_STdC/driver/: ais328dq_reg.c
  group MEMS/ais3624dq
    ../../ais3624dq_STdC/examples/: ais3624dq_read_data_polling.c ais3624dq_self_test.c
    ../../ais3624dq_STdC/driver/: ais3624dq_reg.c
  group MEMS/asm330lhb
    ../../asm330lhb_STdC/examples/: asm330lhb_read_data_polling.c
    ../../asm330lhb_STdC/driver/: asm330lhb_reg.c
  group MEMS/asm330lhbg1
    ../../asm330lhbg1_STdC/examples/: asm330lhbg1_read_data_polling.c
    ../../asm330lhbg1_STdC/driver/: asm330lhbg1_reg.c
  group MEMS/asm330lhh
    ../../asm330lhh_STdC/examples/: asm330lhh_fifo_read.c asm330lhh_free_fall.c asm330lhh_orientation.c asm330lhh_read_data_pollng.c asm330lhh_read_timestamp.c asm330lhh_wake_up.c
    ../../asm330lhh_STdC/driver/: asm330lhh_reg.c
  group MEMS/asm330lhhx
    ../../asm330lhhx_STdC/examples/: asm330lhhx_activity.c asm330lhhx_free_fall.c asm330lhhx_multi_read_fifo_simple.c asm330lhhx_orientation_6d_4d.c asm330lhhx_read_data_interrupt.c asm330lhhx_read_data_polling.c asm330lhhx_read_data_simple_offset.c asm330lhhx_read_data_simple_timestamp.c asm330lhhx_self_test.c asm330lhhx_wake_up.c
    ../../asm330lhhx_STdC/driver/: asm330lhhx_reg.c
  group MEMS/asm330lhhxg1
    ../../asm330lhhxg1_STdC/examples/: asm330lhhxg1_activity.c asm330lhhxg1_free_fall.c asm330lhhxg1_fsm_motion.c asm330lhhxg1_fsm_shake.c asm330lhhxg1_mlc_vehicle_stationary.c asm330lhhxg1_multi_read_fifo_simple.c asm330lhhxg1_orientation_6d_4d.c asm330lhhxg1_read_data_interrupt.c asm330lhhxg1_read_data_polling.c asm330lhhxg1_read_data_simple_offset.c asm330lhhxg1_read_data_simple_timestamp.c asm330lhhxg1_self_test.c asm330lhhxg1_wake_up.c
    ../../asm330lhhxg1_STdC/driver/: asm330lhhxg1_reg.c
  group MEMS/asm330lhm
    ../../asm330lhm_STdC/examples/: asm330lhm_fifo_read.c asm330lhm_free_fall.c asm330lhm_orientation.c asm330lhm_read_data_pollng.c asm330lhm_read_timestamp.c asm330lhm_wake_up.c
    ../../asm330lhm_STdC/driver/: asm330lhm_reg.c
  group MEMS/h3lis100dl
    ../../h3lis100dl_STdC/examples/: h3lis100dl_free_fall.c h3lis100dl_read_data_polling.c h3lis100dl_wake_up.c
    ../../h3lis100dl_STdC/driver/: h3lis100dl_reg.c
  group MEMS/h3lis331dl
    ../../h3lis331dl_STdC/examples/: h3lis331dl_read_data_drdy.c h3lis331dl_read_data_polling.c h3lis331dl_wakeup.c
    ../../h3lis331dl_STdC/driver/: h3lis331dl_reg.c
  group MEMS/hts221
    ../../hts221_STdC/examples/: hts221_read_data_polling.c
    ../../hts221_STdC/driver/: hts221_reg.c
  group MEMS/i3g4250d
    ../../i3g4250d_STdC/examples/: i3g4250d_fifo_read.c i3g4250d_read_data_polling.c i3g4250d_wake_up.c
    ../../i3g4250d_STdC/driver/: i3g4250d_reg.c
  group MEMS/iis2dh
    ../../iis2dh_STdC/examples/: iis2dh_fifo_read.c iis2dh_free_fall.c iis2dh_orientation.c iis2dh_read_data_polling.c iis2dh_self_test.c iis2dh_tap_double.c iis2dh_tap_single.c iis2dh_wake_up.c
    ../../iis2dh_STdC/driver/: iis2dh_reg.c
  group MEMS/iis2dlpc
    ../../iis2dlpc_STdC/examples/: iis2dlpc_activity.c iis2dlpc_free_fall.c iis2dlpc_orientation.c iis2dlpc_read_data_polling.c iis2dlpc_self_test.c iis2dlpc_tap_double.c iis2dlpc_tap_single.c iis2dlpc_wake_up.c
    ../../iis2dlpc_STdC/driver/: iis2dlpc_reg.c
  group MEMS/iis2dulpx
    ../../iis2dulpx_STdC/driver/: iis2dulpx_reg.c
  group MEMS/iis2iclx
    ../../iis2iclx_STdC/examples/: iis2iclx_fsm_tilt.c iis2iclx_read_data_polling.c
    ../../iis2iclx_STdC/driver/: iis2iclx_reg.c
  group MEMS/iis2mdc
    ../../iis2mdc_STdC/examples/: iis2mdc_read_data_polling.c iis2mdc_self_test.c
    ../../iis2mdc_STdC/driver/: iis2mdc_reg.c
  group MEMS/iis328dq
    ../../iis328dq_STdC/examples/: iis328dq_read_data_polling.c iis328dq_self_test .c
    ../../iis328dq_STdC/driver/: iis328dq_reg.c
  group MEMS/iis3dhhc
    ../../iis3dhhc_STdC/driver/: iis3dhhc_reg.c
  group MEMS/iis3dwb
    ../../iis3dwb_STdC/driver/: iis3dwb_reg.c
    ../../iis3dwb_STdC/examples/: iis3dwb_self_test.c iis3dwb_wake_up.c
  group MEMS/iis3dwb10is
    ../../iis3dwb10is_STdC/driver/: iis3dwb10is_reg.c
  group MEMS/ilps22qs
    ../../ilps22qs_STdC/examples/: ilps22qs_fifo.c ilps22qs_qvar_read_data_polling.c ilps22qs_read_data_polling.c
    ../../ilps22qs_STdC/driver/: ilps22qs_reg.c
  group MEMS/ilps28qsw
    ../../ilps28qsw_STdC/examples/: ilps28qsw_ah_qvar_press_interleaved.c ilps28qsw_ah_qvar_read_data_polling.c ilps28qsw_fifo.c ilps28qsw_fifo_interleaved_data.c ilps28qsw_read_data_polling.c
    ../../ilps28qsw_STdC/driver/: ilps28qsw_reg.c
  group MEMS/ism303dac
    ../../ism303dac_STdC/examples/: ism303dac_read_data_polling.c ism303dac_self_test.c
    ../../ism303dac_STdC/driver/: ism303dac_reg.c
  group MEMS/ism330bx
    ../../ism330bx_STdC/examples/: ism330bx_activity.c ism330bx_fifo.c ism330bx_mlc_tilt.c ism330bx_mlc_vibration_monitoring.c ism330bx_pedometer.c ism330bx_qvar_read_data_polling.c ism330bx_read_data_polling.c ism330bx_self_test.c ism330bx_sensor_fusion.c ism330bx_wake_up.c
    ../../ism330bx_STdC/driver/: ism330bx_reg.c
  group MEMS/ism330dhcx
    ../../ism330dhcx_STdC/examples/: ism330dhcx_fsm_freefall_detection.c ism330dhcx_read_data_polling.c ism330dhcx_self_test.c ism330dhcx_sensor_hub_iis2mdc.c ism330dhcx_sensor_hub_iis2mdc_fifo_timestamp.c
    ../../ism330dhcx_STdC/driver/: ism330dhcx_reg.c
  group MEMS/ism330dlc
    ../../ism330dlc_STdC/examples/: ism330dlc_read_data_polling.c ism330dlc_self_test.c
    ../../ism330dlc_STdC/driver/: ism330dlc_reg.c
  group MEMS/ism330is
    ../../ism330is_STdC/examples/: ism330is_ispu_norm.c ism330is_read_data_drdy.c ism330is_read_data_polling.c ism330is_self_test.c
    ../../ism330is_STdC/driver/: ism330is_reg.c
  group MEMS/l20g20is
    ../../l20g20is_STdC/driver/: l20g20is_reg.c
  group MEMS/l3gd20h
    ../../l3gd20h_STdC/examples/: l3gd20h_read_data_polling.c l3gd20h_self_test.c
    ../../l3gd20h_STdC/driver/: l3gd20h_reg.c
  group MEMS/lis25ba
    ../../lis25ba_STdC/driver/: lis25ba_reg.c
  group MEMS/lis2de12
    ../../lis2de12_STdC/examples/: lis2de12_read_data_polling.c
    ../../lis2de12_STdC/driver/: lis2de12_reg.c
  group MEMS/lis2dh
    ../../lis2dh_STdC/examples/: lis2dh_read_data_polling.c lis2dh_read_fifo.c lis2dh_self_test.c
    ../../lis2dh_STdC/driver/: lis2dh_reg.c
  group MEMS/lis2dh12
    ../../lis2dh12_STdC/examples/: lis2dh12_read_data_polling.c lis2dh12_read_fifo.c lis2dh12_self_test.c
    ../../lis2dh12_STdC/driver/: lis2dh12_reg.c
  group MEMS/lis2dlc12
    ../../lis2dlc12_STdC/driver/: lis2dlc12_reg.c
  group MEMS/lis2doc
    ../../lis2doc_STdC/examples/: lis2doc_activity.c lis2doc_free_fall.c lis2doc_orientation.c lis2doc_read_data_polling.c lis2doc_read_data_single.c lis2doc_read_fifo.c lis2doc_self_test.c lis2doc_tap_double.c lis2doc_tap_single.c lis2doc_wake_up.c
    ../../lis2doc_STdC/driver/: lis2doc_reg.c
  group MEMS/lis2ds12
    ../../lis2ds12_STdC/driver/: lis2ds12_reg.c
  group MEMS/lis2dtw12
    ../../lis2dtw12_STdC/examples/: lis2dtw12_activity.c lis2dtw12_free_fall.c lis2dtw12_orientation.c lis2dtw12_read_data_polling.c lis2dtw12_read_fifo.c lis2dtw12_self_test.c lis2dtw12_tap_double.c lis2dtw12_tap_single.c lis2dtw12_wake_up.c
    ../../lis2dtw12_STdC/driver/: lis2dtw12_reg.c
  group MEMS/lis2du12
    ../../lis2du12_STdC/examples/: lis2du12_free_fall.c lis2du12_read_data_drdy.c lis2du12_read_data_fifo.c lis2du12_read_data_polling.c lis2du12_self_test.c lis2du12_sixd.c lis2du12_tap.c
    ../../lis2du12_STdC/driver/: lis2du12_reg.c
  group MEMS/lis2dux12
    ../../lis2dux12_STdC/examples/: lis2dux12_free_fall.c lis2dux12_fsm_glance.c lis2dux12_mlc_activity_mobile.c lis2dux12_pedo_fifo.c lis2dux12_pedometer.c lis2dux12_read_data_drdy.c lis2dux12_read_data_polling.c lis2dux12_read_fifo.c lis2dux12_self_test.c lis2dux12_sixd.c lis2dux12_tap.c lis2dux12_tilt.c lis2dux12_wakeup.c
    ../../lis2dux12_STdC/driver/: lis2dux12_reg.c
  group MEMS/lis2duxs12
    ../../lis2duxs12_STdC/examples/: lis2duxs12_free_fall.c lis2duxs12_fsm_glance.c lis2duxs12_mlc_activity_mobile.c lis2duxs12_pedo_fifo.c lis2duxs12_pedometer.c lis2duxs12_qvar_read_data.c lis2duxs12_read_data_drdy.c lis2duxs12_read_data_polling.c lis2duxs12_read_fifo.c lis2duxs12_self_test.c lis2duxs12_sixd.c lis2duxs12_tap.c lis2duxs12_tilt.c lis2duxs12_wakeup.c
    ../../lis2duxs12_STdC/driver/: lis2duxs12_reg.c
  group MEMS/lis2dw12
    ../../lis2dw12_STdC/examples/: lis2dw12_activity.c lis2dw12_free_fall.c lis2dw12_orientation.c lis2dw12_read_data_polling.c lis2dw12_read_data_single.c lis2dw12_read_fifo.c lis2dw12_self_test.c lis2dw12_tap_double.c lis2dw12_tap_single.c lis2dw12_wake_up.c
    ../../lis2dw12_STdC/driver/: lis2dw12_reg.c
  group MEMS/lis2hh12
    ../../lis2hh12_STdC/examples/: lis2hh12_data_polling.c lis2hh12_self_test.c
    ../../lis2hh12_STdC/driver/: lis2hh12_reg.c
  group MEMS/lis2mdl
    ../../lis2mdl_STdC/examples/: lis2mdl_hard_iron.c lis2mdl_int_conf.c lis2mdl_read_data_int.c lis2mdl_read_data_polling.c lis2mdl_read_data_single.c lis2mdl_self_test.c
    ../../lis2mdl_STdC/driver/: lis2mdl_reg.c
  group MEMS/lis331dlh
    ../../lis331dlh_STdC/driver/: lis331dlh_reg.c
  group MEMS/lis3de
    ../../lis3de_STdC/driver/: lis3de_reg.c
  group MEMS/lis3dh
    ../../lis3dh_STdC/examples/: lis3dh_free_fall.c lis3dh_multi_read_fifo.c lis3dh_orientation.c lis3dh_read_data_polling.c lis3dh_self_test.c lis3dh_tap_double.c lis3dh_tap_single.c lis3dh_wake_up.c
    ../../lis3dh_STdC/driver/: lis3dh_reg.c
  group MEMS/lis3dhh
    ../../lis3dhh_STdC/driver/: lis3dhh_reg.c
  group MEMS/lis3dsh
    ../../lis3dsh_STdC/driver/: lis3dsh_reg.c
  group MEMS/lis3mdl
    ../../lis3mdl_STdC/driver/: lis3mdl_reg.c
  group MEMS/lps22ch
    ../../lps22ch_STdC/driver/: lps22ch_reg.c
  group MEMS/lps22df
    ../../lps22df_STdC/examples/: lps22df_fifo.c lps22df_read_data_drdy.c lps22df_read_data_polling.c lps22df_read_fifo_irq.c
    ../../lps22df_STdC/driver/: lps22df_reg.c
  group MEMS/lps22hb
    ../../lps22hb_STdC/examples/: lps22hb_multi_read_fifo.c lps22hb_read_data_polling.c lps22hb_read_one_shot.c
    ../../lps22hb_STdC/driver/: lps22hb_reg.c
  group MEMS/lps22hh
    ../../lps22hh_STdC/examples/: lps22hh_read_data_drdy.c lps22hh_read_data_polling.c lps22hh_read_fifo_irq.c
    ../../lps22hh_STdC/driver/: lps22hh_reg.c
  group MEMS/lps25hb
    ../../lps25hb_STdC/examples/: lps25hb_read_data_polling.c
    ../../lps25hb_STdC/driver/: lps25hb_reg.c
  group MEMS/lps27hhtw
    ../../lps27hhtw_STdC/driver/: lps27hhtw_reg.c
  group MEMS/lps27hhw
    ../../lps27hhw_STdC/driver/: lps27hhw_reg.c
  group MEMS/lps28dfw
    ../../lps28dfw_STdC/examples/: lps28dfw_fifo.c lps28dfw_read_data_polling.c
    ../../lps28dfw_STdC/driver/: lps28dfw_reg.c
  group MEMS/lps28dfw5
    ../../lps28dfw5_STdC/driver/: lps28dfw5_reg.c
  group MEMS/lps33hw
    ../../lps33hw_STdC/driver/: lps33hw_reg.c
  group MEMS/lps33k
    ../../lps33k_STdC/examples/: lps33k_read_data_polling.c lps33k_read_one_shot.c
    ../../lps33k_STdC/driver/: lps33k_reg.c
  group MEMS/lps33w
    ../../lps33w_STdC/driver/: lps33w_reg.c
  group MEMS/lsm303agr
    ../../lsm303agr_STdC/driver/: lsm303agr_reg.c
  group MEMS/lsm303ah
    ../../lsm303ah_STdC/driver/: lsm303ah_reg.c
  group MEMS/lsm6ds3
    ../../lsm6ds3_STdC/examples/: lsm6ds3_activity.c lsm6ds3_enable_timestamp_hw.c lsm6ds3_fifo_stream_to_fifo.c lsm6ds3_free_fall.c lsm6ds3_multi_read_fifo.c lsm6ds3_multi_read_fifo_simple.c lsm6ds3_orientation.c lsm6ds3_read_data_polling.c lsm6ds3_self_test.c lsm6ds3_sensor_hub_lis2mdl_lps22hb.c lsm6ds3_tap_double.c lsm6ds3_tap_single.c lsm6ds3_tilt.c lsm6ds3_wake_up.c
    ../../lsm6ds3_STdC/driver/: lsm6ds3_reg.c
  group MEMS/lsm6ds3tr-c
    ../../lsm6ds3tr-c_STdC/driver/: lsm6ds3tr-c_reg.c
  group MEMS/lsm6dsl
    ../../lsm6dsl_STdC/driver/: lsm6dsl_reg.c
  group MEMS/lsm6dsm
    ../../lsm6dsm_STdC/driver/: lsm6dsm_reg.c
  group MEMS/lsm6dso
    ../../lsm6dso_STdC/examples/: lsm6dso_activity.c lsm6dso_compressed_fifo.c lsm6dso_fifo.c lsm6dso_fifo_pedo.c lsm6dso_free_fall.c lsm6dso_fsm.c lsm6dso_offset.c lsm6dso_orientation.c lsm6dso_pedometer.c lsm6dso_read_data_polling.c lsm6dso_self_test.c lsm6dso_sensor_hub_lis2mdl.c lsm6dso_sensor_hub_lps22hh.c lsm6dso_tap.c lsm6dso_tilt.c lsm6dso_timestamp.c lsm6dso_wake_up.c
    ../../lsm6dso_STdC/driver/: lsm6dso_reg.c
  group MEMS/lsm6dso16is
    ../../lsm6dso16is_STdC/examples/: lsm6dso16is_ispu_norm.c lsm6dso16is_read_data_drdy.c lsm6dso16is_read_data_polling.c lsm6dso16is_self_test.c lsm6dso16is_sensor_hub.c
    ../../lsm6dso16is_STdC/driver/: lsm6dso16is_reg.c
  group MEMS/lsm6dso32
    ../../lsm6dso32_STdC/driver/: lsm6dso32_reg.c
  group MEMS/lsm6dso32x
    ../../lsm6dso32x_STdC/examples/: lsm6dso32x_activity.c lsm6dso32x_compressed_fifo.c lsm6dso32x_fifo.c lsm6dso32x_fifo_pedo.c lsm6dso32x_free_fall.c lsm6dso32x_fsm.c lsm6dso32x_mlc.c lsm6dso32x_offset.c lsm6dso32x_orientation.c lsm6dso32x_pedometer.c lsm6dso32x_read_data_int.c lsm6dso32x_read_data_polling.c lsm6dso32x_self_test.c lsm6dso32x_single_double_tap.c lsm6dso32x_tilt.c lsm6dso32x_timestamp.c lsm6dso32x_wake_up.c
    ../../lsm6dso32x_STdC/driver/: lsm6dso32x_reg.c
  group MEMS/lsm6dsox
    ../../lsm6dsox_STdC/examples/: lsm6dsox_activity.c lsm6dsox_fifo.c lsm6dsox_fifo_compressed.c lsm6dsox_fifo_step.c lsm6dsox_free_fall.c lsm6dsox_fsm_glance.c lsm6dsox_fsm_raw.c lsm6dsox_fsm_sh_mag_anomalies_detection.c lsm6dsox_mlc.c lsm6dsox_multi_conf.c lsm6dsox_offset.c lsm6dsox_orientation.c lsm6dsox_pedometer.c lsm6dsox_read_data_drdy.c lsm6dsox_read_data_polling.c lsm6dsox_self_test.c lsm6dsox_sh_fifo_lis2mdl.c lsm6dsox_sh_fifo_lis2mdl_timestamp.c lsm6dsox_sh_fifo_lps22hh.c lsm6dsox_sh_lis2mdl.c lsm6dsox_sh_lis2mdl_drdy.c lsm6dsox_sh_lis2mdl_mlc.c lsm6dsox_tap.c lsm6dsox_tilt.c lsm6dsox_timestamp.c lsm6dsox_wake_up.c mag_anomalies_detection_fsm.h
    ../../lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group MEMS/lsm6dsr
    ../../lsm6dsr_STdC/driver/: lsm6dsr_reg.c
  group MEMS/lsm6dsrx
    ../../lsm6dsrx_STdC/driver/: lsm6dsrx_reg.c
  group MEMS/lsm6dsv
    ../../lsm6dsv_STdC/examples/: lsm6dsv_fifo.c lsm6dsv_free_fall.c lsm6dsv_read_data_irq.c lsm6dsv_read_data_polling.c lsm6dsv_self_test.c lsm6dsv_sensor_fusion.c lsm6dsv_sensor_hub.c lsm6dsv_single_double_tap.c lsm6dsv_six_d_position.c lsm6dsv_wakeup.c
    ../../lsm6dsv_STdC/driver/: lsm6dsv_reg.c
  group MEMS/lsm6dsv16b
    ../../lsm6dsv16b_STdC/examples/: lsm6dsv16b_fifo.c lsm6dsv16b_read_data_polling.c lsm6dsv16b_self_test.c
    ../../lsm6dsv16b_STdC/driver/: lsm6dsv16b_reg.c
  group MEMS/lsm6dsv16bx
    ../../lsm6dsv16bx_STdC/examples/: lsm6dsv16bx_activity.c lsm6dsv16bx_fifo.c lsm6dsv16bx_fsm_fourd.c lsm6dsv16bx_fsm_glance.c lsm6dsv16bx_mlc_activity.c lsm6dsv16bx_pedometer.c lsm6dsv16bx_qvar_read_data_polling.c lsm6dsv16bx_read_data_polling.c lsm6dsv16bx_self_test.c lsm6dsv16bx_sensor_fusion.c lsm6dsv16bx_wake_up.c
    ../../lsm6dsv16bx_STdC/driver/: lsm6dsv16bx_reg.c
  group MEMS/lsm6dsv16x
    ../../lsm6dsv16x_STdC/examples/: lsm6dsv16x_compressed_fifo.c lsm6dsv16x_fifo.c lsm6dsv16x_fifo_irq.c lsm6dsv16x_free_fall.c lsm6dsv16x_fsm_fourd.c lsm6dsv16x_fsm_glance.c lsm6dsv16x_mlc_gym.c lsm6dsv16x_qvar_read_data_polling.c lsm6dsv16x_read_data_irq.c lsm6dsv16x_read_data_polling.c lsm6dsv16x_self_test.c lsm6dsv16x_sensor_fusion.c lsm6dsv16x_sensor_hub.c lsm6dsv16x_single_double_tap.c lsm6dsv16x_six_d_position.c lsm6dsv16x_wakeup.c
    ../../lsm6dsv16x_STdC/driver/: lsm6dsv16x_reg.c
  group MEMS/lsm6dsv256x
    ../../lsm6dsv256x_STdC/examples/: lsm6dsv256x_hg_wakeup.c lsm6dsv256x_read_data_drdy.c lsm6dsv256x_read_data_polling.c lsm6dsv256x_read_fifo.c
    ../../lsm6dsv256x_STdC/driver/: lsm6dsv256x_reg.c
  group MEMS/lsm6dsv320x
    ../../lsm6dsv320x_STdC/examples/: lsm6dsv320x_hg_wakeup.c lsm6dsv320x_read_data_drdy.c lsm6dsv320x_read_data_polling.c lsm6dsv320x_read_fifo.c
    ../../lsm6dsv320x_STdC/driver/: lsm6dsv320x_reg.c
  group MEMS/lsm6dsv32x
    ../../lsm6dsv32x_STdC/examples/: lsm6dsv32x_fifo.c lsm6dsv32x_fifo_irq.c lsm6dsv32x_fsm_fourd.c lsm6dsv32x_fsm_glance.c lsm6dsv32x_mlc_gym.c lsm6dsv32x_read_data_polling.c lsm6dsv32x_self_test.c lsm6dsv32x_sensor_fusion.c lsm6dsv32x_single_double_tap.c lsm6dsv32x_six_d_position.c
    ../../lsm6dsv32x_STdC/driver/: lsm6dsv32x_reg.c
  group MEMS/lsm6dsvd
    ../../lsm6dsvd_STdC/examples/: lsm6dsvd_activity.c lsm6dsvd_fifo.c lsm6dsvd_pedometer.c lsm6dsvd_read_data_polling.c lsm6dsvd_self_test.c lsm6dsvd_sensor_fusion.c lsm6dsvd_wake_up.c
    ../../lsm6dsvd_STdC/driver/: lsm6dsvd_reg.c
  group MEMS/lsm9ds1
    ../../lsm9ds1_STdC/driver/: lsm9ds1_reg.c
  group MEMS/st1vafe6ax
    ../../st1vafe6ax_STdC/examples/: st1vafe6ax_fifo.c st1vafe6ax_read_data_polling.c st1vafe6ax_self_test.c st1vafe6ax_vafe_read_data.c
    ../../st1vafe6ax_STdC/driver/: st1vafe6ax_reg.c
  group MEMS/st_fifo
    ../../_resources/FIFO_Utility_Tool/: st_fifo.c
  group MEMS/steng1ax
    ../../steng1ax_STdC/examples/: steng1ax_read_data_drdy.c steng1ax_read_data_polling.c steng1ax_read_fifo.c
    ../../steng1ax_STdC/driver/: steng1ax_reg.c
  group MEMS/sths34pf80
    ../../sths34pf80_STdC/driver/: sths34pf80_reg.c
    ../../sths34pf80_STdC/examples/: sths34pf80_tmos_data_drdy.c sths34pf80_tmos_data_polling.c sths34pf80_tmos_presence_detection.c
  group MEMS/stts22h
    ../../stts22h_STdC/examples/: stts22h_read_data_polling.c
    ../../stts22h_STdC/driver/: stts22h_reg.c
  group MEMS/stts751
    ../../stts751_STdC/driver/: stts751_reg.c
