# IAR project nucleo-h503rb.ewp, settings and files
configuration nucleo-h503rb (ARM, debug)
  General.OGChipSelectEditMenu: STM32H503RB ST STM32H503RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H503xx; NUCLEO_H503RB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32H5xx_HAL_Driver/Src; ../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../Drivers/CMSIS/Include; C:\Users\visconta\Projects\STdC\lsm6dsv16x_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv16x\FourD position recognition; C:\Users\visconta\Projects\STdC\_resources\STMems_Finite_State_Machine\application_examples\lsm6dsv16x\Glance detection; C:\Users\visconta\Projects\STdC\_resources\STMems_Machine_Learning_Core\application_examples\lsm6dsv16x\gym_activity_recognition; C:\Users\visconta\Projects\STdC\_resources\FIFO_Utility_Tool; C:\Users\visconta\Projects\STdC\lis2mdl_STdC\driver; C:\Users\visconta\Projects\STdC\lps22df_STdC\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: nucleo-h503rb.hex
  ILINK.IlinkOutputFile: nucleo-h503rb.out
  ILINK.IlinkIcfFile: stm32h503xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: board.c gpdma.c gpio.c i3c.c icache.c main.c stm32h5xx_hal_msp.c stm32h5xx_it.c usart.c usb.c
    ../../_resources/FIFO_Utility_Tool/: st_fifo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Drivers/LIS2MDL
    ../../lis2mdl_STdC/driver/: lis2mdl_reg.c
  group Drivers/LPS22DF
    ../../lps22df_STdC/driver/: lps22df_reg.c
  group Drivers/LSM6DSV16X
    ../../lsm6dsv16x_STdC/examples/: lsm6dsv16x_compressed_fifo.c lsm6dsv16x_fifo.c lsm6dsv16x_fifo_irq.c lsm6dsv16x_free_fall.c lsm6dsv16x_fsm_fourd.c lsm6dsv16x_fsm_glance.c lsm6dsv16x_mlc_gym.c lsm6dsv16x_qvar_read_data_polling.c lsm6dsv16x_read_data_irq.c lsm6dsv16x_read_data_polling.c lsm6dsv16x_self_test.c lsm6dsv16x_sensor_fusion.c lsm6dsv16x_sensor_hub.c lsm6dsv16x_single_double_tap.c lsm6dsv16x_six_d_position.c lsm6dsv16x_wakeup.c
    ../../lsm6dsv16x_STdC/driver/: lsm6dsv16x_reg.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_ll_usb.c stm32h5xx_util_i3c.c
